## boards/shields/navi10/Kconfig.defconfig
```kconfig
if SHIELD_NAVI10

config ZMK_KEYBOARD_NAME
    default "navi10"

endif # SHIELD_NAVI10
```
